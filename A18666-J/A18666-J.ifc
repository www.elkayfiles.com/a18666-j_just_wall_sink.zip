Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-02-12T19:50:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 12 19:50:54 2024 * Host: ZILBY3SGS3 * Database: C:\Users\SMalaya\AppData\Local\Temp\9545bd37-ec58-4252-8e0a-27bba02c68fe\0c65cbad-9977-4a20-be6a-7ba53c804e0c\ifc * Database version: 5507 * Database creation date: Mon Feb 12 19:50:53 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 12 19:50:53 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 12 19:50:53 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: A18666-J:A18666-J, A18666-J:A18666-J:763795
In: Level 1
Type - Material: Metal - Steel - Stainless - Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: A18666-J
Pset_DistributionFlowElementCommon - Reference: A18666-J; sets with these values: 2
